v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -90 0 0 0 {name=p1 lab=Input1}
C {ipin.sym} -90 50 0 0 {name=p2 lab=Input2
}
C {opin.sym} 50 0 0 0 {name=p3 lab=Output1
}
C {opin.sym} 50 50 0 0 {name=p4 lab=Output2

}
C {code_shown.sym} -170 110 0 0 {name=s1 only_toplevel=false value=blabla}
