v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {tline.sym} 30 -30 0 0 {name=T1 Z0=50 TD=1n}
C {vsource.sym} -260 50 0 0 {name=V1 value=3 savecurrent=false}
C {vsource.sym} -200 50 0 0 {name=V2 value=3 savecurrent=false}
