v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {title.sym} 160 40 0 0 {name=l1 author="Dharma Anargya Jowandy"}
