v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/afe-icdec-teknofest-2026/CTLE/filterred_power_detector_sizing.sym} 350 -270 0 0 {name=x1}
C {/foss/designs/afe-icdec-teknofest-2026/CTLE/voltage-to-i-converter.sym} 350 -420 0 0 {name=x2}
